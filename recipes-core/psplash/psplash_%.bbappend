FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SPLASH_IMAGES:forcevariable = "file://msb-splash.png;outsuffix=default"

