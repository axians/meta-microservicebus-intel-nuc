FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://intel-nuc.scc"

